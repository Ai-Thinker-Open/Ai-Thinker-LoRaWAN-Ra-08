# Keil uVision project asr_template.uvprojx, settings and files
target project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: asr_template +hex
  AfterMake: .\utils\genbinary.bat
